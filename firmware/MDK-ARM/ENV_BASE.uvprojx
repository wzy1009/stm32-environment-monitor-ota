# Keil uVision project ENV_BASE.uvprojx, settings and files
target ENV_APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08008000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ENV_APP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,ENV_OTA_APP
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x08008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../Core/Src/: main.c oled.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c board_io.c dht11.c monitor_state.c usart.c esp_at.c esp_stream.c cloud_mqtt.c cloud_task.c at24c02.c http_image.c i2c.c ota_download.c ota_image.c ota_meta.c ota_notice.c spi.c system_clock.c utils_md5.c w25q128.c
    ../Boot/: boot_main.c boot_flash.c boot_install.c boot_enter.c
  group HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c
  group Startup
    ./: startup_stm32f103xe.s
target ENV_BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x08007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ENV_BOOT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,ENV_BOOT
  c include: as above
  memory RVCT4: ROM 0x08000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: boot_layout.sct
software components: CMSIS:CORE 4.3.0
