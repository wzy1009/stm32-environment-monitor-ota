# Keil uVision project OTA_BOOT.uvprojx, settings and files
target OTA_BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: OTA_BOOT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../../firmware/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../../firmware/Drivers/STM32F1xx_HAL_Driver/Inc;../../firmware/Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../firmware/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\boot_layout.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c boot.c boot_check.c boot_enter.c gpio.c i2c.c spi.c usart.c ota_meta.c at24c02.c stm32f1xx_it.c stm32f1xx_hal_msp.c ota_image.c utils_md5.c w25q128.c ota_install.c boot_display.c oled.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../firmware/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
